*Title: lab 2 simulation

.option savecurrents

.include ../mat/ngspice_t24.txt

.control

*makes plots in color
set hcopypscolor=0
set color0=white
set color1=black
set color2=red

op

echo "********************************************"
echo  "Transient analysis"
echo "********************************************"
tran 1e-5 20e-3

hardcopy trans2.ps v(1) v(6)
echo trans2_FIG

echo "********************************************"
echo  "Frequency analysis"
echo "********************************************"

ac dec 1000 0.1 1MEG

hardcopy acm.ps vdb(1) vdb(6) ylabel 'magnitude (dB)'
echo acm_FIG

set units = degrees
let pe(1) = vp(1) + 90
let pe(6) = vp(6) + 90
hardcopy acp.ps pe(1) pe(6) ylabel 'phase (degrees)'
echo acp_FIG

quit
.endc
