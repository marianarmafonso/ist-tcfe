*Title: lab 2 simulation

.option savecurrents

.include ../mat/ngspice_t23.txt

.control

op

*makes plots in color
set hcopypscolor=0
set color0=white
set color1=black
set color2=red

echo "********************************************"
echo  "Transient analysis"
echo "********************************************"
tran 1e-5 20e-3

hardcopy trans.ps v(6)
echo trans_FIG

quit
.endc
